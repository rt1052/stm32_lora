# Keil uVision project APP.uvprojx, settings and files
target APP (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lora +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output ./output/lora.bin ./output/lora.axf
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\User;..\app;..\bsp;..\stm32lib\Libraries\inc;..\stm32lib\CMSIS\CM3\CoreSupport;..\stm32lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\lora;..\ucosii\Ports;..\ucosii\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../User/: main.c stm32f10x_it.c stm32f10x_it.h stm32f10x_conf.h
    ../user/: os_cfg.h app_cfg.h
  group app
    ../app/: app.c app.h ctrl.c lora.c
  group bsp
    ../bsp/: bsp.c bsp.h usart.c spi.c dht11.c
  group stm32lib
    ../stm32lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../stm32lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../stm32lib/Libraries/src/: stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_flash.c
    ../stm32lib/Startup/: startup_stm32f10x_md.s
  group lora
    ../lora/: fifo.c radio.c sx1276.c sx1276-Hal.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group ucosii
    ../ucosii/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
    ../ucosii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
software components: CMSIS:CORE 4.3.0
